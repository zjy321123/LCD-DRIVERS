# Keil uVision project LVGL-GUIDER.uvprojx, settings and files
target LVGL-GUIDER (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IROM(0x08000000-0x807FFFF) IRAM2(0x20030000-0x200323FF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: LVGL-GUIDER +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32WB55xx
  c misc: --diag_suppress=188
  c include: ../Core/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Drivers/CMSIS/Include;../Bsp/Task;../Bsp/Lcd;../Bsp/Mygui;../Bsp/Guider/custom;../Bsp/Guider/generated;../Bsp/Guider/custom;../Bsp/Guider/generated;../Bsp/Guider/generated/guider_customer_fonts;../Bsp/Guider/generated/guider_fonts;../Bsp/Guider/generated/images;../Bsp/MyGuiGuiderUIs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20030000 size 0x2400
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c memorymap.c spi.c tim.c stm32wbxx_it.c stm32wbxx_hal_msp.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Task
    ../Bsp/Task/: task.c
  group Lcd
    ../Bsp/Lcd/: lcd.c
  group Mygui
    ../Bsp/Mygui/: mygui.c
  group Guider
    ../Bsp/Guider/custom/: custom.c
    ../Bsp/Guider/generated/: events_init.c gui_guider.c setup_scr_screen.c setup_scr_screen_1.c setup_scr_screen_2.c setup_scr_screen_3.c setup_scr_screen_4.c widgets_init.c
    ../Bsp/Guider/generated/guider_fonts/: lv_font_arial_12.c lv_font_arial_16.c
  group myguideruis
    ../Bsp/MyGuiGuiderUIs/: myguideruis.c
software components: CMSIS:CORE 5.4.0, LVGL:Essential 9.2.1, LVGL:Porting:Display 9.2.1, LVGL:Porting:Input 9.2.1
